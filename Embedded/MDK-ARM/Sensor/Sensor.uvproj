# Keil uVision project Sensor.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Sensor
  c flags: Optim=1
  c define: __USE_LCD,DBG_ITM
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STM32F10x.s
  group Interrupts
    ./: IRQ.c
  group Retarget
    ./: Retarget.c
  group Source Code
    ./: Setup.c Main.c Sensor.c
  group Library
    ./: Serial.c lcd.c
    ./STM32-Lib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  c define: __USE_LCD,DBG_ITM
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target C++test - MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Sensor
  c flags: Optim=1
  c define: __USE_LCD,DBG_ITM
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target C++test - Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Sensor
  c flags: Optim=1
  c define: __USE_LCD,DBG_ITM,STM32F10X_HD
  c include: .;.\STM32-Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
