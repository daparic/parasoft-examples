# IAR project Sensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Sensor.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration STM32F103ZE-SK (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: src; STM32-Lib\inc
  OBJCOPY.OOCOutputFile: Sensor.srec
  ILINK.IlinkIcfFile: src\stm32f10x_flash.icf
  group (top)
    src/: cortexm3_macro.s init-STM32F103ZE-SK.c main-Sim.c main-STM32F103ZE-SK.c sensor-Sim.c sensor-STM32F103ZE-SK.c sensor.c stm32f10x_it.c stm32f10x_vector.c
  group LCD
    src/: drv_glcd.c glcd_ll.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group STM32-Lib
    STM32-Lib/src/: stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c
